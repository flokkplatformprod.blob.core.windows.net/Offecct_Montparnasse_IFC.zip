Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: montparnasse.ifc
Time: 2016-09-02T07:41:14
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Montparnasse
ePset_BIMobject_Lena - Seat Material: Fabric; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Montparnasse; SKU (BO_prodsku): Montparnasse; ManufacturName (BO_Manufac): Offecct; ProductFamily (BO_prodfam): Furniture; ProductGroup (BO_prodgroup): table; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; EditionNumber (BO_edinum): 1; Width (BO_width): 750; Height (BO_height): 800; Depth (BO_depth): 820; Weight (BO_weight): 8.5; QR (BO_boqrurl): http://bimobject.com/offecct/product/Montparnasse; ProductDataUrl (BO_prodaturl): bimobject.com/offecct/product/Montparnasse; TechnicalDescription (BO_techcert): http://www.offecct.se/files/downloads/Prodblad_eng/OFFECCT_MONTPARNASSE_EN_LOW.pdf; MaterialMain (BO_mainmat): Upholstery; MaterialSecondary (BO_secmat): Metal; BimObjectCategory (BO_bocat): Armchairs; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; RegionEurope (BO_europe): AL, AT, AX, BA, BE, BG, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GR, HR, HU, IE, IS, IT, JE, LI, LT, LU, LV, MC, ME, NL, NO, PL, PT, RO, RS, RU, SE, SI, SK, UA; RegionNorthAmerica (BO_northamerica): AW, BB, BS, CA, CR, GT, HN, JM, MX, PA, PR, SX, TT, US, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BR, CL, CO, EC, FK, PE, PY, UY, VE; RegionMiddleEast (BO_middleeast): AE, BH, EG, IL, IR, JO, KW, LB, OM, PS, QA, SA, TR; RegionAsia (BO_asia): AZ, BD, CN, HK, ID, IN, JP, KH, KR, KZ, MV, MY, PH, SG, TH, TW, VN; RegionOceania (BO_oceania): AU, NZ, PF; RegionAfrica (BO_africa): LR, MA, MU, SC, TN, TZ, ZA
